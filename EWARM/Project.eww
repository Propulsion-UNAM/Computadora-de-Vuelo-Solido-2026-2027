<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\CV_solido_2026.ewp</path>
  </project>
  <batchBuild />
</workspace>
